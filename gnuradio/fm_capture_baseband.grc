options:
  parameters:
    description: My first AM radio receiver.
    generate_options: qt_gui
    id: first_am_rx
    output_language: python
    title: AM Receiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 96e6
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 94.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: chan_width/20
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '11'
    value: '5'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: working_samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fm_c96.3M_s400k.iq
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'volume/10 '
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq - center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,chan_width/2,transition_width)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(working_samp_rate/1000)
    interp: '32'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
