options:
  parameters:
    description: Play a channelized 400 kSps FM baseband recording.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: fm_iq
    output_language: python
    title: Recorded FM Receiver
  states: {}

blocks:
- name: recorded_freq
  id: variable_qtgui_entry
  parameters:
    label: Recorded RF frequency
    type: real
    value: 96.3e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '11'
    value: '5'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: working_samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/yshulm01/dev/yshulman/CM3070/gnuradio/fm_c96.3M_s400k/fm_c96.3M_s400k.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'volume/10 '
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: recorded_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(working_samp_rate/1000)
    interp: '32'
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', analog_wfm_rcv_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
